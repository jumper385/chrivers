## drivers/chenry_sensor/Kconfig
```kconfig
menuconfig CHENRY_SENSOR
	bool "A sensor to detect chenrys"
	help
	  Enable chenry sensor "sensor"
```
